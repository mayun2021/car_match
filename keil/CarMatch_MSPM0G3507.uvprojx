# Keil uVision project CarMatch_MSPM0G3507.uvprojx, settings and files
target CarMatch_MSPM0G3507 (6070000::V6.7::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CarMatch_MSPM0G3507 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__;TARGET_MSPM0
  c include: ..\include;..\generated;..\sdk\source;..\sdk\source\third_party\CMSIS\Core\Include
  asm include: ..\sdk\source\third_party\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group Generated SysConfig
    ../generated/: ti_msp_dl_config.c ti_msp_dl_config.h
    ../: README.md
  group Application
    ../src/: main.c
    ../src/app/: robot_app.c pid.c
    ../src/drivers/: display.c oled.c k230_protocol.c line_sensor.c motor.c mpu6050.c servo.c
    ../src/platform/: hal_ti_mspm0.c
    ../include/: hal.h robot_app.h robot_config.h robot_types.h servo.h k230_protocol.h
  group More Headers
    ../include/: line_sensor.h motor.h mpu6050.h oled.h
  group TI DriverLib
    ../sdk/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
